FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
      file://enable-gui.cfg \
"
